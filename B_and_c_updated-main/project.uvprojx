# Keil uVision project project.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.6.1
  cpu: IRAM(0x20000000,0x00018000) IRAM2(0x10000000,0x00008000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group main
    ./src/: main.c
  group setup
    ./src/: startup_stm32l476xx.s stm32l476xx.h SysClock.h SysClock.c SysTimer.h SysTimer.c
  group DMA
    ./src/: DMA.h UART.h I2C.c I2C.h SPI.c SPI.h DMA.c UART.c
  group peripherals
    ./src/: LED.h LED.c motor.c motor.h accelerometer.c accelerometer.h
software components: CMSIS:CORE 5.6.0
